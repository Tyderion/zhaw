# Keil uVision project spi_display.uvprojx, settings and files
target SPI_Display (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CT_Board_HS14_M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.4.0.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(180000000) ELITTLE
  output: spi_display
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress 6314
  group Source SPI-Display
    ./app/: main.c lcd_io.c cmd_lcd.c hal_spi.c cmd_touch.c
software components: CMSIS:CORE 4.3.0, Device:Startup 3.0.3, HAL:FMC 3.0.1, HAL:GPIO 3.0.1, HAL:PWR 2.2.0, HAL:RCC 3.0.1
