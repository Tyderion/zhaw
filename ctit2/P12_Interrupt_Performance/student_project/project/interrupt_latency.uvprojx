# Keil uVision project interrupt_latency.uvprojx, settings and files
target Interrupt_latency (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: CT_Board_HS14_M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.3.0.5
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(180000000) ELITTLE
  output: interrupt_latency
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress 6314
  group app
    ./app/: main.c hal_exti.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.2.0, HAL:CT Board:LCD 2.2.0, HAL:FMC 2.2.0, HAL:GPIO 2.2.0, HAL:PWR 2.2.0, HAL:RCC 2.2.0, HAL:TIMER 2.2.0
