# Keil uVision project TicTacToe.uvprojx, settings and files
target TicTacToe (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CT_Board_HS14_M0 STMicroelectronics
  pack: InES.CTBoard14_DFP.4.0.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TicTacToe
  c flags: Optim=1 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: lib/driver_touchscreen.lib lib/hal_spi.lib lib/tictactoe.lib lib_debug_with_src/tictactoe_ui_touchscreen.lib
  group app
    ./app/: main.c game.c
software components: Device:Startup 2.1.1, HAL:FMC 2.1.1, HAL:GPIO 2.1.1, HAL:PWR 2.1.1, HAL:RCC 2.1.1
